# IAR project BIM.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; FEATURE_FIXED_IMAGE; FEATURE_OAD; BOOT_LOADER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../app/CC26xx; ../../../Profiles/OAD/CC26xx; ../../../../../Components/ble/include; ../../../../../Components/osal/include; ../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../Components/hal/target/_common/cc26xx; ../../../../../Components/hal/include; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BIM.hex
  ILINK.IlinkOutputFile: BIM.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: bim_cc26xx.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_OADTargetDebug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; FEATURE_FIXED_IMAGE; FEATURE_OAD
  group (top)
    ./: bim_cc26xx.icf
  group Application
    ../app/CC26xx/: bim_main.c
    ../../../Profiles/OAD/CC26xx/: oad.h oad_target.h oad_target_externalFlash.c oad_target_internalFlash.c
